# Keil uVision project Cadence.uvprojx, settings and files
target Cadence (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Cadence +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: .eide\deps;.;Core\CMSIS\CMSIS\Core\Include;Core\nRF52\modules\nrfx\mdk;Core\nRF52\modules\components\ble\peer_manager;Core\nRF52\modules\components\ble\common;Core\nRF52\modules\components\ble\ble_advertising;Core\nRF52\modules\components\ble\nrf_ble_gatt;Core\nRF52\modules\components\ble\nrf_ble_qwr;Core\nRF52\modules\components\ble\ble_services\ble_bas;Core\nRF52\modules\components\ble\ble_services\ble_cscs;Core\nRF52\modules\components\ble\ble_services\ble_dis;Core\nRF52\modules\nrfx\soc;Core\nRF52\modules\nrfx\drivers\include;Core\nRF52\modules\components\libraries\button;Core\nRF52\modules\components\libraries\util;Core\nRF52\modules\components\libraries\atomic;Core\nRF52\modules\components\libraries\atomic_fifo;Core\nRF52\modules\components\libraries\atomic_flags;Core\nRF52\modules\components\libraries\balloc;Core\nRF52\modules\components\libraries\crc16;Core\nRF52\modules\components\libraries\fds;Core\nRF52\modules\components\libraries\fstorage;Core\nRF52\modules\components\libraries\hardfault;Core\nRF52\modules\components\libraries\memobj;Core\nRF52\modules\components\libraries\pwr_mgmt;Core\nRF52\modules\components\libraries\ringbuf;Core\nRF52\modules\components\libraries\sensorsim;Core\nRF52\modules\components\libraries\sortlist;Core\nRF52\modules\components\libraries\strerror;Core\nRF52\modules\components\libraries\timer;Core\nRF52\modules\components\softdevice\common;Core\nRF52\modules\components\libraries\experimental_section_vars;Core\nRF52\modules\components\libraries\log;Core\nRF52\modules\components\libraries\log\src;Core\nRF52\modules\components\libraries\mutex;Core\nRF52\modules\nrfx;.\Core\nRF52\modules\nrfx\templates\nRF52840;Core\nRF52\integration\nrfx;Core\nRF52\modules\components\ble\ble_services\ble_bas_c;Core\nRF52\modules\components\ble\ble_services\ble_dis_c;Core\nRF52\modules\components\ble\ble_dtm;Core\nRF52\modules\components\ble\ble_racp;Core\nRF52\modules\components\libraries\delay;Core\nRF52\integration\nrfx\legacy;Core\nRF52\modules\nrfx\hal;Core\nRF52\modules\components\softdevice\s140;Core\nRF52\modules\components\softdevice\s140\headers;Core\nRF52\modules\components\softdevice\s140\headers\nrf52
  asm define: SOFTDEVICE_PRESENT ,NRF_SD_BLE_API_VERSION=7 ,NRF52_PAN_74,NRF52 ,FLOAT_ABI_HARD ,CONFIG_GPIO_AS_PINRESET ,APP_TIMER_V2 ,APP_TIMER_V2_RTC1_ENABLED ,S140,NRF52840_XXAA
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20002260 size 0x3dda0
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Sources
    ./: bmi_controller.c Source.c
    Core/nRF52/modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
    ./: sdk_config.h
  group nRF_SoftDevice
    Core/nRF52/modules/components/softdevice/common/: nrf_sdh_ble.c nrf_sdh_soc.c nrf_sdh.c
  group nRF_Libraries
    Core/nRF52/modules/components/libraries/atomic_fifo/: nrf_atfifo.c
    Core/nRF52/modules/components/libraries/atomic_flags/: nrf_atflags.c
    Core/nRF52/modules/components/libraries/atomic/: nrf_atomic.c
    Core/nRF52/modules/components/libraries/balloc/: nrf_balloc.c
    Core/nRF52/modules/components/libraries/button/: app_button.c
    Core/nRF52/modules/components/libraries/crc16/: crc16.c
    Core/nRF52/modules/components/libraries/experimental_section_vars/: nrf_section_iter.c
    Core/nRF52/modules/components/libraries/fds/: fds.c
    Core/nRF52/modules/components/libraries/fstorage/: nrf_fstorage_sd.c nrf_fstorage.c
    Core/nRF52/modules/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    Core/nRF52/modules/components/libraries/sortlist/: nrf_sortlist.c
    Core/nRF52/modules/components/libraries/timer/: app_timer2.c drv_rtc.c
    Core/nRF52/modules/components/libraries/util/: app_error_handler_keil.c app_error_weak.c app_error.c app_util_platform.c nrf_assert.c
  group nRF_Drivers
    Core/nRF52/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_twi.c nrf_drv_uart.c
    Core/nRF52/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_twi.c nrfx_uart.c nrfx_uarte.c
    Core/nRF52/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    Core/nRF52/modules/nrfx/soc/: nrfx_atomic.c
  group nRF_BLE_Services
    Core/nRF52/modules/components/ble/ble_services/ble_bas/: ble_bas.c
    Core/nRF52/modules/components/ble/ble_services/ble_cscs/: ble_cscs.c ble_sc_ctrlpt.c
    Core/nRF52/modules/components/ble/ble_services/ble_dis/: ble_dis.c
  group nRF_BLE
    Core/nRF52/modules/components/ble/ble_advertising/: ble_advertising.c
    Core/nRF52/modules/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    Core/nRF52/modules/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    Core/nRF52/modules/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    Core/nRF52/modules/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager_handler.c peer_manager.c pm_buffer.c security_dispatcher.c security_manager.c
